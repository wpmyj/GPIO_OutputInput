# Keil uVision project GPIO_OutputInput.uvproj, settings and files
target GPIO_OutputInput (ARM-ADS)
  device: M058LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GPIO_OutputInput +hex
  c flags: wLevel=2
  c include: .\;.\User;.\libM051Series\StdDriver\inc;.\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;.\libM051Series\CMSIS\CM0\CoreSupport
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Library files
    ./LibM051Series/StdDriver/src/: retarget.c adc.c clk.c gpio.c pwm.c sys.c timer.c
  group RTX_Config
    ./RTX_Config/: RTX_Conf_CM.c
  group CMSIS files
    ./LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ./LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group USER
    ./User/: main.c Key_Board.c lcd.c Time.c Sensor.c hongwai.c
